* SPICE3 file created from pralayout1.ext - technology: scmos

M1000 out in vdd vdd pfet w=1.4u l=0.4u
+  ad=4.2p pd=8.8u as=1.96p ps=5.6u
M1001 out in gnd gnd nfet w=1.4u l=0.4u
+  ad=4.2p pd=8.8u as=1.96p ps=5.6u
C0 vdd in 0.29fF
C1 out vdd 0.13fF
C2 out gnd 0.12fF
C3 in gnd 0.26fF
C4 vdd gnd 3.51fF
